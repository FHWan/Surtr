# Keil uVision project BirdFlight_V2.0.uvprojx, settings and files
target BirdFlight_V2.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: betaflight_4.1.0_TMOTORF4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\Core;..\Driver;..\Libraries\inc;..\System;..\User;..\uCOS-III\Bsp;..\uCOS-III\Config;..\uCOS-III\Core;..\uCOS-III\CPU;..\uCOS-III\Lib;..\uCOS-III\Port;..\Hardware\SPI;..\Hardware\MPU6500;..\Hardware\IMU_AHRS;..\Hardware\LSM303;..\Libraries\CMSIS\Include;..\Parameter;..\Mymath\Limits;..\Hardware\Flash;..\Hardware\MCPWM;..\Hardware\TIMER_AHRS_INNER;..\Hardware\ADC_BATTERY;..\Hardware\General_Gpio;..\Hardware\Bluetooth;..\Hardware\USART_BLUETOOTH;..\Mymath\Position;..\Mymath\Digital_filter;..\Hardware\USART_Ultra;..\Mymath\SimpleDigitalFilter;..\Control\Attitude_control;..\Control\Position_control;..\Hardware\TIMER_Timing;..\Control\PID_control;..\Mymath\MahonyAHRS;..\Mymath\Calibrate;..\Hardware\IIC;..\Hardware\MS5611;..\Hardware\PPM;..\Mymath\MathTool;..\Mymath\matrix3;..\Hardware\USART_TOF;..\Hardware\TofMiniPlus;..\Hardware\USART_T265;..\Mymath\ExtensionalKalmanFilter;..\Mymath\MadgwickAHRS;..\Hardware\USART_Flow
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../Doc/: readme.txt
  group Core
    ../Core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Libraries
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
    ../Libraries/inc/: misc.h
  group System
    ../System/: explore_system.c explore_systick.c
  group uC/OS III - BSP
    ../uCOS-III/Bsp/: bsp.c
  group uC/OS III - CPU
    ../uCOS-III/CPU/: cpu_core.c cpu_c.c cpu_a.asm
  group uC/OS III - Lib
    ../uCOS-III/Lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC/OS III - Core
    ../uCOS-III/Core/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS III - Port
    ../uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS III - Config
    ../uCOS-III/Config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group User
    ../User/: stm32f4xx_main.c stm32f4xx_conf.h stm32f4xx_it.c Task.c
  group Hardware
    ../Hardware/SPI/: SPI3.c
    ../Hardware/MPU6500/: MPU6500.c
    ../Hardware/IMU_AHRS/: IMU_AHRS.c
    ../Hardware/LSM303/: LSM303D.c
    ../Hardware/TIMER_Timing/: Timer5_Timing.c
    ../Hardware/Flash/: Flash.c
    ../Hardware/MCPWM/: mcpwm.c
    ../Hardware/ADC_BATTERY/: Adc_Battery.c
    ../Hardware/General_Gpio/: General_Gpio.c
    ../Hardware/USART_BLUETOOTH/: Usart3toBluetooth.c
    ../Hardware/Bluetooth/: Bluetooth.c
    ../Hardware/MS5611/: MS5611.c
    ../Hardware/PPM/: PPM.c
    ../Hardware/IIC/: i2c.c
    ../Hardware/USART_TOF/: Uart4toTOF.c
    ../Hardware/TofMiniPlus/: TofMiniPlus.c
    ../Hardware/USART_T265/: Usart6toVision.c
    ../Hardware/USART_Flow/: Usart5toFlow.c
  group Control
    ../Control/Attitude_control/: Attitude_control.c
    ../Control/Position_control/: Position_control.c
    ../Control/PID_control/: PID_control.c
  group Parameter
    ../Parameter/: DronePara.h Data_PC.c Type_conversion.c Data_deal.c Visiondata_deal.c t265_deal.c Flow_deal.c
  group Mymath
    ../Mymath/Limits/: Limits.c
    ../Mymath/Digital_filter/: digital_filter.c
    ../Mymath/Position/: PositionEstimation.c
    ../Mymath/SimpleDigitalFilter/: SimpleDigitalFiltering.c
    ../Mymath/Calibrate/: Calibrate.c
    ../Mymath/matrix3/: matrix3.c
    ../Mymath/MathTool/: MathTool.c
    ../Mymath/ExtensionalKalmanFilter/: ExtensionalKalmanFilter.c Matrix.c
    ../Mymath/MahonyAHRS/: MahonyAHRS.c
